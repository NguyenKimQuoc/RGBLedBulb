<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RGBLedBulb.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RGBLedBulb</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>RGBLedBulb</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>RGBLedBulb</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>RGBLedBulb</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


